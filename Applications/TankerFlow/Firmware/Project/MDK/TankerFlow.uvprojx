# Keil uVision project TankerFlow.uvprojx, settings and files
target APM32F030RC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F030RC Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: TankerFlow +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F030_MINI,APM32F030xC
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include;..\..\Drivers\SGM41511;..\..\Drivers\GNSS\ATGM336;..\..\Drivers\Modem\MC610;..\..\Drivers\FlowMeter;..\..\Middleware\Protocol\NMEA;..\..\Middleware\Protocol\AT;..\..\Platform\Port;..\..\Middleware\Protocol\Modbus;..\..\Drivers\FlowMeter\ZELZ
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f030.s startup_apm32f051.s startup_apm32f072.s startup_apm32f091.s
  group StdPeriphLib
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Board
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c
    ../../Application/: flow_session.c flow_meter_app.c
  group System
    ../../Source/: apm32f0xx_int.c
  group BSP
    ../../Source/: bsp_tick.c bsp_debug_uart.c bsp_ring_buffer.c bsp_gpio.c bsp_uart.c bsp_i2c.c bsp_adc.c bsp_peripherals.c
  group Platform-APM32
    ../../Platform/APM32/: platform_port_apm32.c
  group Diagnostics
    ../../Source/: bsp_selftest.c
  group Drivers-Charger
    ../../Drivers/SGM41511/: sgm41511.c
  group Drivers-GNSS
    ../../Drivers/GNSS/ATGM336/: gnss.c
  group Drivers-Modem
    ../../Drivers/Modem/MC610/: modem_4g.c mc610_tcp.c mc610_tcp_tx.c
  group Middleware-AT
    ../../Middleware/Protocol/AT/: at_core.c
  group Middleware-NMEA
    ../../Middleware/Protocol/NMEA/: nmea_parser.c
  group Drivers-FlowMeter
    ../../Drivers/FlowMeter/: flow_meter.c flow_meter_service.c
    ../../Middleware/Protocol/Modbus/: modbus_rtu.c
    ../../Drivers/FlowMeter/ZELZ/: zelz_flow_meter.c
target APM32F051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F051R8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_MINI,APM32F051x8
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group left out of the first target's files
    ../../Drivers/Modem/MC610/: mc610_tcp.c mc610_tcp_tx.c
target APM32F072 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group left out of the first target's files
    ../../Drivers/Modem/MC610/: mc610_tcp.c mc610_tcp_tx.c
target APM32F091 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F091VC Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F091_MINI,APM32F091xC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group left out of the first target's files
    ../../Drivers/Modem/MC610/: mc610_tcp.c mc610_tcp_tx.c
